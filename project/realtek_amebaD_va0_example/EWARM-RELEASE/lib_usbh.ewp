# IAR project lib_usbh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\soc\realtek\amebad\fwlib\usb_otg\host\inc; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_hp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\amebad\cmsis; $TOOLKIT_DIR$\inc\c
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_usbd.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../component/soc/realtek/amebad/fwlib/usb_otg/host/src/: dwc_common_os.c dwc_os.c dwc_otg_cil.c dwc_otg_cil_intr.c dwc_otg_common.c dwc_otg_common_rom.c dwc_otg_dbg.c dwc_otg_driver.c dwc_otg_driver_rom.c dwc_otg_hcd.c dwc_otg_hcd_intr.c dwc_otg_hcd_os.c dwc_otg_hcd_queue.c usb.c
