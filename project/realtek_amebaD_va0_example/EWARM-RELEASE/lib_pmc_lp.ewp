# IAR project lib_pmc_lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __ARM_FEATURE_DSP=0
  ICCARM.CCIncludePath2: ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_lp; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_LP\; ..\..\..\component\soc\realtek\amebad\cmsis; ..\..\..\component\soc\realtek\amebad\wifi_fw\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\common\api; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\api\platform; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_wifi_fw.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../component/soc/realtek/amebad/misc/: rtl8721d_freertos_pmu.c
    ../../../component/soc/realtek/amebad/fwlib/ram_lp/: rtl8721dlp_pmc.c rtl8721dlp_pmc_ram.c
    ../../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721dlp_sleepcfg_lib.c
