# IAR project lib_wps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_WPS2
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lib_wps.srec
  ILINK.IlinkOutputFile: lib_wps.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src/crypto
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: crypto_internal-modexp.c dh_group5.c dh_groups.c random.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/rom/: rom_wps_aes-cbc.c rom_wps_aes-internal-dec.c rom_wps_aes-internal-enc.c rom_wps_aes-internal.c rom_wps_sha256-internal.c rom_wps_sha_256.c
  group src/eap_common
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/eap_common/: eap_common.c eap_wsc_common.c
  group src/eap_peer
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/eap_peer/: eap_wsc.c
  group src/tls
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/tls/rom/: rom_wps_big_num.c rom_wps_libtommath.c
  group src/utils
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/utils/: os_freertos.c wpa_debug.c wpabuf.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/utils/rom/: rom_wps_os_freertos.c
  group src/wps
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/wps/: wps.c wps_attr_build.c wps_attr_parse.c wps_attr_process.c wps_common.c wps_dev_attr.c wps_enrollee.c wps_validate.c
  group wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wps_protocol_handler.c
