<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\km4_application.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\km4_bootloader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\km4_secure.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_ac3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_amr.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_coap.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_eap.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_ekho.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_gsm610.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_haac.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_hmp3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_http2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_httpc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_httpd.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_libogg.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_mmfv2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_mp3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_opus.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_opusenc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_opusfile.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_rtp_codec.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_rtsp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_tftp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_usbd.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_usbh.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_v4l2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_websocket.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_wlan.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_wlan_mp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_wlan_lp.ewp</path>
    </project>	
    <project>
        <path>$WS_DIR$\lib_wlan_lt.ewp</path>
    </project>		
    <project>
        <path>$WS_DIR$\lib_wps.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib_dct.ewp</path>
    </project>
    <batchBuild />
</workspace>
