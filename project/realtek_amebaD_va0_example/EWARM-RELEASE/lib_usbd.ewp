# IAR project lib_usbd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\soc\realtek\amebad\fwlib\usb_otg\device\inc; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_hp; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\os; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\amebad\cmsis; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_usbd.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../component/soc/realtek/amebad/fwlib/usb_otg/device/src/: dwc_otg_cil.c dwc_otg_cil_intr.c dwc_otg_common.c dwc_otg_driver.c dwc_otg_driver_rom.c dwc_otg_pcd.c dwc_otg_pcd_intr.c dwc_otg_pcd_os.c usb.c usb_composite.c usb_ep_autoconfig.c
