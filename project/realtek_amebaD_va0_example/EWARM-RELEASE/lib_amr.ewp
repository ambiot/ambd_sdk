# IAR project lib_amr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure\; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\audio\opencore-amr\amrnb; ..\..\..\component\common\audio\opencore-amr\amrwb; ..\..\..\component\common\audio\opencore-amr\oscl; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_nb\common\include; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_nb\dec\include; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_nb\dec\src; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_nb\enc\include; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_nb\enc\src; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_wb\dec\include; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\amr_wb\dec\src; ..\..\..\component\common\audio\opencore-amr\opencore\codecs_v2\audio\gsm_amr\common\dec\include; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_amr.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../../../component/common/audio/opencore-amr/opencore/codecs_v2/audio/gsm_amr/amr_nb/dec/src/: a_refl.cpp agc.cpp amrdecode.cpp b_cn_cod.cpp bgnscd.cpp c_g_aver.cpp d1035pf.cpp d2_11pf.cpp d2_9pf.cpp d3_14pf.cpp d4_17pf.cpp d8_31pf.cpp d_gain_c.cpp d_gain_p.cpp d_plsf.cpp d_plsf_3.cpp d_plsf_5.cpp dec_amr.cpp dec_gain.cpp dec_input_format_tab.cpp dec_lag3.cpp dec_lag6.cpp dtx_dec.cpp ec_gains.cpp ex_ctrl.cpp if2_to_ets.cpp int_lsf.cpp lsp_avg.cpp ph_disp.cpp post_pro.cpp preemph.cpp pstfilt.cpp pvgsmamrdecoder.cpp qgain475_tab.cpp sp_dec.cpp wmf_to_ets.cpp
    ../../../component/common/audio/opencore-amr/opencore/codecs_v2/audio/gsm_amr/amr_nb/common/src/: add.cpp az_lsp.cpp bitno_tab.cpp bitreorder_tab.cpp c2_9pf_tab.cpp div_32.cpp div_s.cpp extract_h.cpp extract_l.cpp gains_tbl.cpp gc_pred.cpp get_const_tbls.cpp gmed_n.cpp gray_tbl.cpp grid_tbl.cpp int_lpc.cpp inv_sqrt.cpp inv_sqrt_tbl.cpp l_abs.cpp l_deposit_h.cpp l_deposit_l.cpp l_shr_r.cpp log2.cpp log2_norm.cpp log2_tbl.cpp lsfwt.cpp lsp.cpp lsp_az.cpp lsp_lsf.cpp lsp_lsf_tbl.cpp lsp_tab.cpp mult_r.cpp negate.cpp norm_l.cpp norm_s.cpp overflow_tbl.cpp ph_disp_tab.cpp pow2.cpp pow2_tbl.cpp pred_lt.cpp q_plsf.cpp q_plsf_3.cpp q_plsf_3_tbl.cpp q_plsf_5.cpp q_plsf_5_tbl.cpp qua_gain_tbl.cpp reorder.cpp residu.cpp round.cpp set_zero.cpp shr.cpp shr_r.cpp sqrt_l.cpp sqrt_l_tbl.cpp sub.cpp syn_filt.cpp weight_a.cpp window_tab.cpp
    ../../../component/common/audio/opencore-amr/opencore/codecs_v2/audio/gsm_amr/amr_wb/dec/src/: agc2_amr_wb.cpp band_pass_6k_7k.cpp dec_acelp_2p_in_64.cpp dec_acelp_4p_in_64.cpp dec_alg_codebook.cpp dec_gain2_amr_wb.cpp deemphasis_32.cpp dtx_decoder_amr_wb.cpp get_amr_wb_bits.cpp highpass_400hz_at_12k8.cpp highpass_50hz_at_12k8.cpp homing_amr_wb_dec.cpp interpolate_isp.cpp isf_extrapolation.cpp isp_az.cpp isp_isf.cpp lagconceal.cpp low_pass_filt_7k.cpp median5.cpp mime_io.cpp noise_gen_amrwb.cpp normalize_amr_wb.cpp oversamp_12k8_to_16k.cpp phase_dispersion.cpp pit_shrp.cpp pred_lt4.cpp preemph_amrwb_dec.cpp pvamrwb_math_op.cpp pvamrwbdecoder.cpp q_gain2_tab.cpp qisf_ns.cpp qisf_ns_tab.cpp qpisf_2s.cpp qpisf_2s_tab.cpp scale_signal.cpp synthesis_amr_wb.cpp voice_factor.cpp wb_syn_filt.cpp weight_amrwb_lpc.cpp
    ../../../component/common/audio/opencore-amr/amrnb/: wrapper.cpp
    ../../../component/common/audio/opencore-amr/amrwb/: wrapper_wb.cpp
