# IAR project lib_wifi_fl_fw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __ARM_FEATURE_DSP=0; CONFIG_LONGPERIOD_TICKLESS=0; CONFIG_1FIRELINE_PowerProtect=1
  ICCARM.CCIncludePath2: ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_lp; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_LP\; ..\..\..\component\soc\realtek\amebad\cmsis; ..\..\..\component\soc\realtek\amebad\wifi_fw\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\common\api; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\api\platform; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_wifi_fw.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../../component/soc/realtek/amebad/wifi_fw/ram/: RTL8721D_AP_Offload_RAM.c RTL8721D_APPSOffload_RAM.c RTL8721D_BTConCurr_RAM.c RTL8721D_Cmd_RAM.c RTL8721D_Coex_RAM.c RTL8721D_CP_FT_TEST_RAM.c RTL8721D_D0_Scan_Offlad_RAM.c RTL8721D_debug_RAM.c RTL8721D_Efuse_RAM.c RTL8721D_FastChannelSwitch_RAM.c RTL8721D_GPIO_RAM.c RTL8721D_GTK_RAM.c RTL8721D_Init_RAM.c RTL8721D_INT_RAM.c RTL8721D_IQK_RAM.c RTL8721D_LockChip_RAM.c RTL8721D_LTECOEX_RAM.c RTL8721D_MLME_RAM.c RTL8721D_NAN_RAM.c RTL8721D_NLO_RAM.c RTL8721D_Normal_Dbg.c RTL8721D_P2POffload_RAM.c RTL8721D_P2PPS_RAM.c RTL8721D_Packet_RAM.c RTL8721D_PhyCfg_RAM.c RTL8721D_PowerCtrl_RAM.c RTL8721D_PowerSave_RAM.c RTL8721D_PSD_RAM.c RTL8721D_RateAdaptive_RAM.c RTL8721D_RealWoW_V2_RAM.c RTL8721D_RegConfig_RAM.c RTL8721D_RLPS_RAM.c RTL8721D_SWTimer_RAM.c RTL8721D_Teredo_RAM.c RTL8721D_TxBF_RAM.c RTL8721D_TxReport_RAM.c RTL8721D_Util_RAM.c RTL8721D_WoWLAN_RAM.c
    ../../../component/soc/realtek/amebad/wifi_fw/test/: RTL8721D_BUF_Test.c RTL8721D_DDMA_Test.c RTL8721D_Efuse_Test.c RTL8721D_FWLBK_Test.c RTL8721D_INT_Test.c RTL8721D_IOPATH_Test.c RTL8721D_REG_Test.c RTL8721D_ROM_Test.c RTL8721D_SecEng_Test.c RTL8721D_Serial_IO_Test.c RTL8721D_test.c
